# Keil uVision project CustomLoader.uvprojx, settings and files
target CustomLoader (6130001::V6.13.1::.\ARMCLANG)
  device: NUC1261SG4AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: IRAM(0x20000000,0x5000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: CustomLoader +hex
  AfterMake: fromelf --bin ".\Build\@L.axf" --output ".\Build\@L.bin"
  AfterMake: fromelf --text -c ".\Build\@L.axf" --output ".\Build\@L.txt"
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: PAGE_SIZE_2048 FLASH_SIZE=262144
  c include: ..\Inc;..\..\common\Inc;..\..\..\nuc1261_cube\HAL\inc;..\..\..\nuc1261_cube\HAL\inc\misc;..\..\..\nuc1261_cube\CMSIS\Include;..\..\..\nuc1261_cube\Device\Nuvoton\NUC1261\Include;..\..\..\nuc1261_cube\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\CustomLoader.sct
  link misc: --map --first='startup_NUC1261.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group Application/MDK-ARM
    ../../../nuc1261_cube/Device/Nuvoton/NUC1261/Source/ARM/: startup_NUC1261.s
  group Application/User
    ../Src/: main.c board.c
  group Cube/StdDrivers
    ../../../nuc1261_cube/StdDriver/src/: clk.c crc.c fmc.c retarget.c sys.c uart.c gpio.c
  group Cube/CMSIS
    ../../../nuc1261_cube/Device/Nuvoton/NUC1261/Source/: system_NUC1261.c
  group CustomLoader
    ../../../: ack_nuc1261_custom_loader.c ack_nuc1261_ota.c
  group Cube/HAL
    ../../../nuc1261_cube/HAL/src/: hal_crc.c hal_flash.c hal_gpio.c hal_sys.c nu_miscutil.c nu_modutil.c nu_rbuf.c peripheral_pins.c pinmap.c
software components: CMSIS:CORE 5.3.0
