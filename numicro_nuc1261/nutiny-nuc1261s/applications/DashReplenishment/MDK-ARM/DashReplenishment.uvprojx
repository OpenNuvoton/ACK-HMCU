# Keil uVision project DashReplenishment.uvprojx, settings and files
target DashReplenishment (6130001::V6.13.1::.\ARMCLANG)
  device: NUC1261SG4AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: IRAM(0x20000000,0x5000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: DashReplenishment +hex
  AfterMake: fromelf --bin ".\Build\@L.axf" --output ".\Build\@L.bin"
  AfterMake: fromelf --text -c ".\Build\@L.axf" --output ".\Build\@L.txt"
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: PAGE_SIZE_2048 FLASH_SIZE=262144
  c include: ..;..\..\..\..;..\..\..\common\Inc;..\..\..\..\nuc1261_cube\CMSIS\Include;..\..\..\..\nuc1261_cube\HAL\inc;..\..\..\..\nuc1261_cube\HAL\inc\misc;..\..\..\..\nuc1261_cube\Device\Nuvoton\NUC1261\Include;..\..\..\..\nuc1261_cube\StdDriver\inc;..\..\..\..\..\..\..\applications\DashReplenishment;..\..\..\..\..\..\..\include;..\..\..\..\..\..\..\core;..\..\..\..\..\..\..\core\generated;..\..\..\..\..\..\..\core\generated\v3avs_capabilities;..\..\..\..\..\..\..\external\nanopb
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\..\..\common\Misc\ack_hmcu_example.sct
  link misc: --map --first='startup_NUC1261.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group ACKApplication
    ../../../../: ack_nuc1261_ota.c ack_nuc1261_platform.c ack_user_device.c
    ../../../../../../../applications/DashReplenishment/: DashReplenishment.c
  group ACKCore
    ../../../../../../../core/: ack_core_alexa_namespace.c ack_core_brightnesscontroller.c ack_core_circularbuffer.c ack_core_colorcontroller.c ack_core_colortemperaturecontroller.c ack_core_common.c ack_core_communication.c ack_core_cooking_common.c ack_core_cooking_mode.c ack_core_cookingcontroller.c ack_core_cookingfoodtemperaturecontroller.c ack_core_cookingfoodtemperaturesensor.c ack_core_cookingpresetcontroller.c ack_core_cookingtemperaturecontroller.c ack_core_cookingtemperaturesensor.c ack_core_cookingtimecontroller.c ack_core_count.c ack_core_crc32.c ack_core_debug_print.c ack_core_device_usage.c ack_core_document.c ack_core_document_wrappers.c ack_core_drs.c ack_core_endpointhealth.c ack_core_event_builder.c ack_core_fixed_memory.c ack_core_food_item.c ack_core_heaplet.c ack_core_inventory_level.c ack_core_item_quantity.c ack_core_lifecycle.c ack_core_logging.c ack_core_math.c ack_core_metrics.c ack_core_modecontroller.c ack_core_module_acp.c ack_core_module_pins.c ack_core_modulediagnostics.c ack_core_outbound_events.c ack_core_percentagecontroller.c ack_core_power_level.c ack_core_powercontroller.c ack_core_processevent.c ack_core_protobuf_utilities.c ack_core_rangecontroller.c ack_core_status.c ack_core_temperature.c ack_core_temperaturesensor.c ack_core_thermostatcontroller.c ack_core_tick64.c ack_core_time_interval.c ack_core_timeholdcontroller.c ack_core_togglecontroller.c ack_core_validation.c ack_core_volume.c ack_core_weight.c
  group ACKCoreGenerated
    ../../../../../../../core/generated/v3avs_capabilities/: V3AVS.pb.c
    ../../../../../../../core/generated/: acp.pb.c
  group ACKExternalNanoPB
    ../../../../../../../external/nanopb/: pb_common.c pb_decode.c pb_encode.c
  group Application/User
    ../../../common/Src/: board.c main.c
  group Application/MDK-ARM
    ../../../../nuc1261_cube/Device/Nuvoton/NUC1261/Source/ARM/: startup_NUC1261.s
  group Cube/CMSIS
    ../../../../nuc1261_cube/Device/Nuvoton/NUC1261/Source/: system_NUC1261.c
  group Cube/StdDrivers
    ../../../../nuc1261_cube/StdDriver/src/: acmp.c adc.c clk.c crc.c ebi.c fmc.c gpio.c i2c.c pdma.c pwm.c retarget.c rtc.c spi.c sys.c timer.c uart.c usbd.c usci_i2c.c usci_spi.c usci_uart.c wdt.c wwdt.c sc.c scuart.c timer_pwm.c
  group Cube/HAL
    ../../../../nuc1261_cube/HAL/src/: hal_crc.c hal_dma.c hal_flash.c hal_gpio.c hal_pwm.c hal_sys.c hal_uart.c nu_miscutil.c nu_modutil.c nu_rbuf.c peripheral_pins.c pinmap.c
