# Keil uVision project DashReplenishment.uvprojx, settings and files
target DashReplenishment (6130001::V6.13.1::.\ARMCLANG)
  device: M032SE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.9
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: DashReplenishment +hex
  AfterMake: fromelf --bin ".\Build\@L.axf" --output ".\Build\@L.bin"
  AfterMake: fromelf --text -c ".\Build\@L.axf" --output ".\Build\@L.txt"
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c include: ..;..\..\..\..;..\..\..\common\Inc;..\..\..\..\m031_cube\CMSIS\Include;..\..\..\..\m031_cube\HAL\inc;..\..\..\..\m031_cube\HAL\inc\misc;..\..\..\..\m031_cube\Device\Nuvoton\M031\Include;..\..\..\..\m031_cube\StdDriver\inc;..\..\..\..\..\..\..\applications\DashReplenishment;..\..\..\..\..\..\..\include;..\..\..\..\..\..\..\core;..\..\..\..\..\..\..\core\generated;..\..\..\..\..\..\..\core\generated\v3avs_capabilities;..\..\..\..\..\..\..\core\generated\v3avs_types;..\..\..\..\..\..\..\external\nanopb
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\..\common\Misc\ack_hmcu_example.sct
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group ACKApplication
    ../../../../: ack_m031_ota.c ack_m031_platform.c
    ../../../../../../: ack_user_device.c
    ../../../../../../../applications/DashReplenishment/: DashReplenishment.c
  group ACKCore
    ../../../../../../../core/: ack_core_alexa_namespace.c ack_core_brightnesscontroller.c ack_core_circularbuffer.c ack_core_colorcontroller.c ack_core_colortemperaturecontroller.c ack_core_common.c ack_core_communication.c ack_core_cooking_common.c ack_core_cookingcontroller.c ack_core_cookingfoodtemperaturecontroller.c ack_core_cookingfoodtemperaturesensor.c ack_core_cookingpresetcontroller.c ack_core_cookingtemperaturecontroller.c ack_core_cookingtemperaturesensor.c ack_core_cookingtimecontroller.c ack_core_drs.c ack_core_endpointhealth.c ack_core_event_builder.c ack_core_factoryreset.c ack_core_heaplet.c ack_core_hostconfig.c ack_core_lifecycle.c ack_core_logging.c ack_core_metrics.c ack_core_modecontroller.c ack_core_module_pins.c ack_core_modulediagnostics.c ack_core_ota.c ack_core_outbound_events.c ack_core_percentagecontroller.c ack_core_powercontroller.c ack_core_processevent.c ack_core_protobuf_utilities.c ack_core_rangecontroller.c ack_core_status.c ack_core_timeholdcontroller.c ack_core_togglecontroller.c ack_core_userguidedsetup.c ack_core_crc32.c ack_core_math.c ack_core_tick64.c ack_core_validation.c
  group ACKCoreGenerated
    ../../../../../../../core/generated/: acp.pb.c
    ../../../../../../../core/generated/v3avs_capabilities/: V3Alexa.pb.c V3AlexaBrightnessController.pb.c V3AlexaColorController.pb.c V3AlexaColorTemperatureController.pb.c V3AlexaCooking.pb.c V3AlexaCookingFoodTemperatureController.pb.c V3AlexaCookingFoodTemperatureSensor.pb.c V3AlexaCookingPresetController.pb.c V3AlexaCookingTemperatureController.pb.c V3AlexaCookingTemperatureSensor.pb.c V3AlexaCookingTimeController.pb.c V3AlexaEndpointHealth.pb.c V3AlexaInventoryLevelSensor.pb.c V3AlexaInventoryLevelUsageSensor.pb.c V3AlexaInventoryUsageSensor.pb.c V3AlexaModeController.pb.c V3AlexaPercentageController.pb.c V3AlexaPowerController.pb.c V3AlexaRangeController.pb.c V3AlexaTimeHoldController.pb.c V3AlexaToggleController.pb.c V3AVS.pb.c
    ../../../../../../../core/generated/v3avs_types/: V3Brightness.pb.c V3BrightnessDelta.pb.c V3CookingMode.pb.c V3Color.pb.c V3ColorTemperatureInKelvin.pb.c V3Connectivity.pb.c V3Count.pb.c V3DateTime.pb.c V3Duration.pb.c V3DeviceState.pb.c V3EnumeratedPowerLevel.pb.c V3FoodItem.pb.c V3IntegralPowerLevel.pb.c V3InventoryConsumed.pb.c V3InventoryCount.pb.c V3InventoryReplaced.pb.c V3ItemQuantity.pb.c V3Length.pb.c V3Level.pb.c V3Mode.pb.c V3ModeDelta.pb.c V3Percentage.pb.c V3PercentageDelta.pb.c V3PowerState.pb.c V3PresetName.pb.c V3Range.pb.c V3RangeDelta.pb.c V3RequiredInteraction.pb.c V3Temperature.pb.c V3TimeInterval.pb.c V3ToggleState.pb.c V3Volume.pb.c V3Weight.pb.c
  group ACKExternalNanoPB
    ../../../../../../../external/nanopb/: pb_common.c pb_decode.c pb_encode.c
  group Application/User
    ../../../common/Src/: board.c main.c
  group Application/MDK-ARM
    ../../../../m031_cube/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Cube/CMSIS
    ../../../../m031_cube/Device/Nuvoton/M031/Source/: system_M031Series.c
  group Cube/StdDrivers
    ../../../../m031_cube/StdDriver/src/: acmp.c adc.c bpwm.c clk.c crc.c ebi.c fmc.c gpio.c i2c.c pdma.c pwm.c qspi.c retarget.c rtc.c spi.c sys.c timer.c uart.c usbd.c usci_i2c.c usci_spi.c usci_uart.c wdt.c wwdt.c
  group Cube/HAL
    ../../../../m031_cube/HAL/src/: hal_crc.c hal_dma.c hal_flash.c hal_gpio.c hal_pwm.c hal_sys.c hal_uart.c nu_miscutil.c nu_modutil.c nu_rbuf.c peripheral_pins.c pinmap.c
