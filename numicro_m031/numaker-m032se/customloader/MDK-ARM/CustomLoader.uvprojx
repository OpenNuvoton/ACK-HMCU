# Keil uVision project CustomLoader.uvprojx, settings and files
target CustomLoader (6130001::V6.13.1::.\ARMCLANG)
  device: M032SE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: CustomLoader +hex
  AfterMake: fromelf --bin ".\Build\@L.axf" --output ".\Build\@L.bin"
  AfterMake: fromelf --text -c ".\Build\@L.axf" --output ".\Build\@L.txt"
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c include: ..\Inc;..\..\common\Inc;..\..\..\m031_cube\HAL\inc;..\..\..\m031_cube\HAL\inc\misc;..\..\..\m031_cube\CMSIS\Include;..\..\..\m031_cube\Device\Nuvoton\M031\Include;..\..\..\m031_cube\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group Application/MDK-ARM
    ../../../m031_cube/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Application/User
    ../Src/: main.c board.c
  group Cube/StdDrivers
    ../../../m031_cube/StdDriver/src/: clk.c crc.c fmc.c retarget.c sys.c uart.c gpio.c
  group Cube/CMSIS
    ../../../m031_cube/Device/Nuvoton/M031/Source/: system_M031Series.c
  group CustomLoader
    ../../../: ack_m031_custom_loader.c ack_m031_ota.c
  group Cube/HAL
    ../../../m031_cube/HAL/src/: hal_crc.c hal_flash.c hal_gpio.c hal_sys.c nu_miscutil.c nu_modutil.c nu_rbuf.c peripheral_pins.c pinmap.c
software components: CMSIS:CORE 5.1.2
