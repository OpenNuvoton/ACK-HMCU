# Keil uVision project HelloWorld.uvprojx, settings and files
target HelloWorld (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M451RG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: HelloWorld +hex
  AfterMake: fromelf --bin ".\Build\@L.axf" --output ".\Build\@L.bin"
  AfterMake: fromelf --text -c ".\Build\@L.axf" --output ".\Build\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: PAGE_SIZE_2048 FLASH_SIZE=262144 DEVICE_UART_RX_DMA=0
  c include: ..;..\..\..\..;..\..\..\common\Inc;..\..\..\..\libraries\CMSIS\Include;..\..\..\..\libraries\HAL\inc;..\..\..\..\libraries\HAL\inc\misc;..\..\..\..\libraries\Device\Nuvoton\M451Series\Include;..\..\..\..\libraries\StdDriver\inc;..\..\..\..\..\..\..\applications\HelloWorld;..\..\..\..\..\..\..\include;..\..\..\..\..\..\..\core;..\..\..\..\..\..\..\core\generated;..\..\..\..\..\..\..\core\generated\v3avs_capabilities;..\..\..\..\..\..\..\external\nanopb
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\common\Misc\ack_hmcu_example.sct
  link misc: --map --first='startup_M451Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group ACKApplication
    ../../../../: ack_numicro_ota.c ack_numicro_platform.c ack_user_device.c
    ../../../../../../../applications/HelloWorld/: HelloWorld.c HelloWorld_Alexa.c HelloWorld_Hardware.c
  group ACKCore
    ../../../../../../../core/: ack_core_alexa_namespace.c ack_core_brightnesscontroller.c ack_core_circularbuffer.c ack_core_colorcontroller.c ack_core_colortemperaturecontroller.c ack_core_common.c ack_core_communication.c ack_core_cooking_common.c ack_core_cooking_mode.c ack_core_cookingcontroller.c ack_core_cookingfoodtemperaturecontroller.c ack_core_cookingfoodtemperaturesensor.c ack_core_cookingpresetcontroller.c ack_core_cookingtemperaturecontroller.c ack_core_cookingtemperaturesensor.c ack_core_cookingtimecontroller.c ack_core_count.c ack_core_crc32.c ack_core_debug_print.c ack_core_device_usage.c ack_core_document.c ack_core_document_wrappers.c ack_core_drs.c ack_core_endpointhealth.c ack_core_event_builder.c ack_core_fixed_memory.c ack_core_food_item.c ack_core_heaplet.c ack_core_inventory_level.c ack_core_item_quantity.c ack_core_lifecycle.c ack_core_logging.c ack_core_math.c ack_core_metrics.c ack_core_modecontroller.c ack_core_module_acp.c ack_core_module_pins.c ack_core_modulediagnostics.c ack_core_outbound_events.c ack_core_percentagecontroller.c ack_core_power_level.c ack_core_powercontroller.c ack_core_processevent.c ack_core_protobuf_utilities.c ack_core_rangecontroller.c ack_core_status.c ack_core_temperature.c ack_core_temperaturesensor.c ack_core_thermostatcontroller.c ack_core_tick64.c ack_core_time_interval.c ack_core_timeholdcontroller.c ack_core_togglecontroller.c ack_core_validation.c ack_core_volume.c ack_core_weight.c
  group ACKCoreGenerated
    ../../../../../../../core/generated/v3avs_capabilities/: V3AVS.pb.c
    ../../../../../../../core/generated/: acp.pb.c
  group ACKExternalNanoPB
    ../../../../../../../external/nanopb/: pb_common.c pb_decode.c pb_encode.c
  group Application/User
    ../../../common/Src/: board.c main.c
  group Application/MDK-ARM
    ../../../../libraries/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
  group Cube/CMSIS
    ../../../../libraries/Device/Nuvoton/M451Series/Source/: system_M451Series.c
  group Cube/StdDrivers
    ../../../../libraries/StdDriver/src/: acmp.c can.c clk.c crc.c dac.c eadc.c ebi.c fmc.c gpio.c i2c.c pdma.c pwm.c retarget.c rtc.c sc.c scuart.c spi.c sys.c timer.c tk.c uart.c usbd.c wdt.c wwdt.c
  group Cube/HAL
    ../../../../libraries/HAL/src/: hal_crc.c hal_dma.c hal_flash.c hal_gpio.c hal_pwm.c hal_sys.c hal_uart.c nu_miscutil.c nu_modutil.c nu_rbuf.c peripheral_pins.c pinmap.c
