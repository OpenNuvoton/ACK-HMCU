# Keil uVision project CustomLoader.uvprojx, settings and files
target CustomLoader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M452RG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: CustomLoader +hex
  AfterMake: fromelf --bin ".\Build\@L.axf" --output ".\Build\@L.bin"
  AfterMake: fromelf --text -c ".\Build\@L.axf" --output ".\Build\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: PAGE_SIZE_2048 FLASH_SIZE=262144
  c include: ..\Inc;..\..\common\Inc;..\..\..\libraries\HAL\inc;..\..\..\libraries\HAL\inc\misc;..\..\..\libraries\CMSIS\Include;..\..\..\libraries\Device\Nuvoton\M451Series\Include;..\..\..\libraries\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\CustomLoader.sct
  link misc: --map --first='startup_M451Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group Application/MDK-ARM
    ../../../libraries/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
  group Application/User
    ../Src/: main.c board.c
  group Cube/StdDrivers
    ../../../libraries/StdDriver/src/: acmp.c can.c clk.c crc.c dac.c eadc.c ebi.c fmc.c gpio.c i2c.c pdma.c pwm.c retarget.c rtc.c sc.c scuart.c spi.c sys.c timer.c tk.c uart.c usbd.c wdt.c wwdt.c
  group Cube/CMSIS
    ../../../libraries/Device/Nuvoton/M451Series/Source/: system_M451Series.c
  group CustomLoader
    ../../../: ack_numicro_custom_loader.c ack_numicro_ota.c
  group Cube/HAL
    ../../../libraries/HAL/src/: hal_crc.c hal_flash.c hal_gpio.c hal_sys.c nu_miscutil.c nu_modutil.c nu_rbuf.c peripheral_pins.c pinmap.c
software components: CMSIS:CORE 5.3.0
